# Keil uVision project MP3_Player.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MP3_Player
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0
  c include: ..\Bsp;..\Application;..\FreeRTOS\include;..\TivaWare_C_Series
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../Application/: main.c control.c KalmanFilter.c bmp.c application.c
  group Bsp
    ../Bsp/: startup_rvmdk.S tft.c usart.c touch.c infrared.c EPIinit.c led.c timer.c uartstdio.c buzzer.c sd.c fatfs_port_tm4c1294.c accelerator.c adc.c PCA9557.c OLED_I2C.c pn532.c i2c.c
    ../../../../Documents/Ti/MP3 Player/TivaWare_C_Series/utils/: cmdline.c
    ../../../../Documents/Ti/MP3 Player/TivaWare_C_Series/third_party/fatfs/src/: ff.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c event_groups.c
  group Libraries
    ../Library/: driverlib.lib IQmathLib.lib
